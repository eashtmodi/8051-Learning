ORG 00H;
	CLR P3.6;
	CLR P3.7;
	MOV R0,#255;
RESTART: MOV P0,#0C0H;0
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#0F9H;1
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#0A4H;2
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#0B0H;3
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#99H;4
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#92H;5
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#082H;6
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#0F8H;7
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#0H;8
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	
	MOV P0,#90H;9
	LCALL DELAY;
	LCALL DELAY;
	LCALL DELAY;
	DJNZ R0,RESTART;

ORG 300H;
	DELAY: MOV R1,#255;
	AGAIN: MOV R2,#255;
	HERE: DJNZ R2,HERE;
	DJNZ R1,AGAIN;
	RET;
	END;