# Keil uVision project 7_SEGMENT_DISPLAY.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: 7_SEGMENT_DISPLAY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 7_SEGMENT_DISPLAY.ASM
