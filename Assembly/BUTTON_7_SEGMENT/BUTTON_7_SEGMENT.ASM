ORG 00H;
	SETB P3.6;
	SETB P3.7;
LOOP:MOV P0,#0C0H;
	MOV R0,#40H;
	MOV R3,#10;
	MOV 40H,#0C0H;0
    MOV 41H,#0F9H; 1
	MOV 42H,#0A4H;2
	MOV 43H,#0B0H;3
	MOV 44H,#99H;4
	MOV 45H,#92H;5
	MOV 46H,#82H;6
	MOV 47H,#0F8H;7
	MOV 48H,#00H;8
RETURN:MOV 49H,#90H;9
	
    THERE: JB P3.6,THERE;
	
	
	 INC R0;
	LCALL DELAY;
	LCALL DELAY;
	MOV P0,@R0;
	DJNZ R3,RETURN;
	SJMP LOOP;

ORG 300H;
	DELAY: MOV R1,#255;
	AGAIN: MOV R2,#255;
	HERE: DJNZ R2,HERE;
	DJNZ R1,AGAIN;
	RET;
	END;