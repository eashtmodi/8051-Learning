ORG 0H;
BACK:   MOV A,#1H;
		MOV P0,A;
		LCALL DELAY;
		MOV A,#2H;
		MOV P0,A;
		LCALL DELAY;
		
		MOV A,#4H;
		MOV P0,A;
		LCALL DELAY;
		MOV A,#8H;
		MOV P0,A;
		LCALL DELAY;
		
		MOV A,#10H;
		MOV P0,A;
		LCALL DELAY;
		MOV A,#20H;
		MOV P0,A;
		LCALL DELAY;
		
		MOV A,#40H;
		MOV P0,A;
		LCALL DELAY;
		MOV A,#80H;
		MOV P0,A;
		LCALL DELAY;
		
		SJMP BACK;


;END;

ORG 300H;
DELAY:	MOV R0,#0FFH;
REP:	MOV R1,#0FFH;
AGAIN:	DJNZ R1,AGAIN;
	    DJNZ R0,REP;
RET;
END;